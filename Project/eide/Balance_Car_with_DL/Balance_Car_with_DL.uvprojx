# Keil uVision project Balance_Car_with_DL.uvprojx, settings and files
target Balance_Car_with_DL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Balance_Car_with_DL
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: .eide\deps;..\..\..\USER;..\..\..\Libraries\CMSIS;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Source;..\..\..\Libraries\GD32F4xx_standard_peripheral\Include;..\..\..\FreeRTOS\INC;..\..\..\API;..\..\..\Task;..\..\..\FreeRTOS\CORE;..\..\..\Core\Inc;..\..\..\Core\Src;..\..\..\Drivers;..\..\..\Drivers\CMSIS;..\..\..\Drivers\CMSIS\GD\Include;..\..\..\Drivers\GD32_F470_STD_Driver\Source
  asm define: USE_STDPERIPH_DRIVER,GD32F470
  memory RVCT1: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x70000
  memory RVCT7: RAM 0x10000000 size 0x10000
  group USER
    ../../../Libraries/CMSIS/Source/: system_gd32f4xx.c
    ../../../USER/: FreeRTOSConfig.h gd32f4xx_it.c gd32f4xx_it.h gd32f4xx_libopt.h main.c systick.c systick.h
  group Task
    ../../../Task/: car_Task.c
  group STARTUP
    ../../../Libraries/Startup/: startup_gd32f450_470.s
  group SRC
    ../../../Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group INC
    ../../../Libraries/GD32F4xx_standard_peripheral/Include/: gd32f4xx_adc.h gd32f4xx_can.h gd32f4xx_crc.h gd32f4xx_ctc.h gd32f4xx_dac.h gd32f4xx_dbg.h gd32f4xx_dci.h gd32f4xx_dma.h gd32f4xx_enet.h gd32f4xx_exmc.h gd32f4xx_exti.h gd32f4xx_fmc.h gd32f4xx_fwdgt.h gd32f4xx_gpio.h gd32f4xx_i2c.h gd32f4xx_ipa.h gd32f4xx_iref.h gd32f4xx_misc.h gd32f4xx_pmu.h gd32f4xx_rcu.h gd32f4xx_rtc.h gd32f4xx_sdio.h gd32f4xx_spi.h gd32f4xx_syscfg.h gd32f4xx_timer.h gd32f4xx_tli.h gd32f4xx_trng.h gd32f4xx_usart.h gd32f4xx_wwdgt.h
  group FreeRTOS_Port
    ../../../FreeRTOS/PORT/: heap_4.c port.c
  group FreeRTOS_Inc
    ../../../FreeRTOS/INC/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS_Core
    ../../../FreeRTOS/CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group API
    ../../../API/: I2C0.c LED.c motor.c PWM.c USART0.c
